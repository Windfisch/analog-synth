# Repository Windfisch/analog-synth (continued)

## KiCad design hardware/vco_mk1/vco_mk1_windfisch/vco_mk1.kicad_pcb

File hardware/vco_mk1/README.md:

VCO development board mk I
==========================

This board is designed to test several options for the VCO design. It
features:

  - Triangle, pulse and sawtooth wave generation
  - shape adjust (R25). Tune this so that you get a perfect triangle.
  - volt-per-octave input
  - linear and exponential frequency modulation
  - selectable capacitor-coupling for the triangle wave using JP5
  - Boundary adjust: R27-R31. (Increases triangle amplitude while
    lowering its frequency)
  - Rossum compensation ([details](https://www.schmitzbits.de/expo_tutorial/)
    [(or on archive.org)](https://web.archive.org/web/20191216173852/https://www.schmitzbits.de/expo_tutorial/))
    for compensating the pitch drop at higher pitches. Can be enabled by
    closing JP2 and disabled by closing JP1 instead. Optionally, R13-15 and
    D1 need not be equipped when disabled
  - Low frequency trim by connecting Q4's source to some millivolts around
    GND instead of GND directly using JP4. Optionally, R1-R3 can be spared
    if not used.
  - DCO mode by applying a square wave to ctl\_override in J2
  - soft sync mode by applying a narrow open-drain pulse to J6
    (e.g. 99% high impedance, 1% connected-to-GND)
  - Digital ringmodulation on the triangle/sawtooth and the square wave,
    configured through JP6 as follows:
    
    - close 12 and 34 for ring-modulated sawtooth
    - close 12 only for ring-modulated triangle
    - close 23 for no ring modulation. U3, Q6 and R41-50 need not be
      equipped then.

There are two different board layouts:

  - [one smaller double-sided layout](vco_mk1_windfisch)
    
  - [one larger layout with components only on the top side](vco_mk1_spitfire), contributed by [SpitfireX](https://github.com/spitfirex).

Revisions
---------

**rev01** can be identified by the marking _"VCO development board mk I"_
(without revision id). Both layouts have been fabricated by [JLCPCB](https://jlcpcb.com)
using the gerber outputs in `gerber-rev01/` or `fab-rev01/`.
Please see the Errata below.

**rev02** can be identified by the text _"VCO development board mk I (rev02)"_.
It has never been fabricated as it contains only silk screen bug fixes.
The differences to rev01 are:

  - U2 is rotated by 180 degrees, swapping U2A/U2C and U2B/U2D, respectively.
  - The pictograms around J3 have been rearranged in the correct order.

Errata (rev01)
--------------

U2 has Vcc and Vee swapped in the schematic. This can be resolved by inserting
U2 into the socket "the wrong way" (i.e. the notch is not on the side where the
PCB wants to have the notch).

SpitfireX's board has the pictograms around J3 reversed. This affects both
the signal pictograms as well as the marking for the capacitor-coupled outputs.

These are fixed in rev02.

Differences from the schematic (rev01)
--------------------------------------

  - U2 is reversed (see Errata)
  - Q1 was equipped, J5, Q2 and Q3 weren't
  - R2 was replaced by a 20k poti
  - R15 was not equipped (no rossum compensation)
  - R18-20 were not equipped yet
  - R10 is missing (no thermal compensation)
  - R9 was replaced by a 100 Ohm resistor
  - R8 was replaced by 10k
  - R4,5,6 were populated with 470k, 220k and 100k, respectively

Testing the board
-----------------

1. Do not equip R15. Close JP1, but not JP2 to disable the rossum compensation.
2. Do not equip U3, and put a jumper on JP6's pins 2+3 to disable ring modulation.
3. Put a jumper on JP4 so that GND is connected.
4. Connect Vcc, GND and Vee to +6V, 0V and -6V (approx.). This configuration can be
   achieved e.g. by a 12 V voltage source, a 1:1 resistor divider and a LM324/LM358
   in buffer configuration for GND.
5. Connect the capacitor-coupled triangle output on J3 to your sound card. Connect GND
   via a capacitor to your sound card.
6. You should hear a triangle wave that can be tuned with R52, R21 (and R31).

Further usage scenarios
-----------------------

### Using the pwm input

The PWM comparator's input is floating. Either connect a voltage source / poti to it that
can range from Vee to Vcc, or tie it to GND using a jumper on J2.

### Tuning the center frequency

Close the JP3 jumper. This will disable the control voltage input and force it to the
"center position". R52 (tune) will be useless. R21 can be used to tune the frequency
at the center position. This is the pitch where the oscillator will exhibit no thermal
drift; the "V/oct" drift (which is compensated by R9-R12, but not perfectly) will
develop around the center pitch. The farther away from this center pitch, the worse the
drift will be.

### Adjusting the schmitt trigger's operation

The triangle's amplitude and pitch can be adjusted by R31.

The triangle's center voltage can be adjusted with R28. This is only relevant when JP5 is
closed, directly attaching the triangle signal to the sawtooth generation circuitry,
bypassing the coupling capacitor. In this case, tuning R28 is required to achieve a clean
sawtooth signal where all teeth are at the same voltage levels.

### Tuning the frequency response

By equipping the Rossum compensation circuitry, closing JP2 and opening JP1, Rossum
compensation can be tuned using R15. This changes the frequency response at high pitches.

By not jumpering GND, but the variable voltage source on JP4, R2 can be used to affect
the frequency response at low pitches.

### Square-like waveform

Connect `square_ctl` to the ring mod input J4. Ideally do not connect it directly,
but buffer the signal using an emitter follower or similar. Loading `square_ctl` will
severly affect the pitch. Then listen to the pulse-mod signal while changing the pwm
voltage on J2.

Soldering workflow
------------------

I soldered the boards in my [local FabLab](https://fablab.fau.de), using a thermal
controlled soldering iron with a flat (screwdriver-like) tip (maybe 1-2mm wide).

I had a printed [BOM](vco_mk1_windfisch/bom.ods) next to me, where I ticked
every component.

Notes for various components:

  - *Resistors and capacitors*: for each component value, do:
    - for each occurence do:
      1. put some tin on one of the pads
      2. heat the tinned pad while sliding the component onto the pad
      3. solder the other pad
    - difficulty: easy
  - *BCM847*: using a stereo microscope, do:
    - 1. use *lots* of flux
    - 2. put some tin on a pad, slide the component onto it
    - 3. more flux
    - 4. solder all pins of the opposite side. Ignore any solder bridges
    - 5. same for the other side.
    - 6. remove the solder bridges by applying flux, then sliding the cleaned
         soldering iron away from the pins. This will take away some tin, until
         finally the solder bridge vanishes due to the surface tension.
    - difficulty: advanced with good equipment, impossible without
  - *through hole components*: straightforward, easy. Order them from flat to large.

Lessons learned
---------------

A capacitor-coupled GND terminal would be useful.

When connecting `square_ctl` to J6 (regardless of whether U3 is installed or not),
this affects the frequency by ca. a semitone. A transistor buffer might help.

Finding the component locations is hard. Prepare one copy of the board layout
per component value, with the respective components highlighted. (Maybe color
coding helps to reduce the amount of copies needed).

Greatly reduce the amount of different component values. Finding the right
component strip and peeling of the covering foil off takes a lot of time.

It might be better to prepare all resistors/capacitors at once, instead of
grouping them by value. Color coding might help.

The double-sided variant wasn't slower to solder than the single-sided.

The BC547 transistor pair don't touch, the footprint should move a bit towards
each other.

Parts:
C1, C2, C5, C6, C7, C8, C9, C10, C11, C12, C13: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 2.2n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: power supply; PinHeader_2x03_P2.54mm_Vertical
J2: control in; PinHeader_2x07_P2.54mm_Vertical
J3: signal out; PinHeader_2x07_P2.54mm_Vertical
J4: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J5: BCM847 breakout socket; DIP-6_W7.62mm_Socket
J6: Conn_01x01_Male; PinHeader_1x01_P2.54mm_Vertical
JP1: Rossum override; SolderDipJumper2alt
JP2: Rossum connect; SolderDipJumper2alt
JP3: expo in; SolderDipJumper2alt
JP4: gnd adjust; SolderDipJumper3alt
JP5: Jumper_2_Open; SolderDipJumper2alt
JP6: ringmod config; SolderDipJumper4alt
Q1: BCM847; SOT-363_SC-70-6
Q2, Q3, Q5: BC547; TO-92_Inline
Q4: 2N7000; TO-92_Inline
Q6: BC327; TO-92_Inline
R1, R3: 1Meg; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R25: 10k; Potentiometer_Bourns_3296W_Vertical
R4, R5, R6: 147k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7: 220k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8: 12k2; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R9: 150; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
R11, R17, R39: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12, R40: 2.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13: 4.7k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R16, R22, R33, R36, R37, R38, R44, R45, R46, R47: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R15: 1k; Potentiometer_Bourns_3296W_Vertical
R18, R19, R20: TODO; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R21: 50k; Potentiometer_Runtron_RM-065_Vertical
R23, R24, R26: 47k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R27, R29, R32, R35, R41, R42, R43, R48, R49, R50, R51: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R28: 20k; Potentiometer_Runtron_RM-065_Vertical
R30, R34: none; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R31: 1Meg; Potentiometer_Runtron_RM-065_Vertical
R52: 1k; Potentiometer_Runtron_RM-065_Vertical
U1, U2: LM324; DIP-14_W7.62mm
U3: 74HC86; DIP-14_W7.62mm

Connections:
+5V: C8.2, J1.2, R44.2, R45.2, R46.2, R47.2, U3.14 (VCC)
B1: J5.2, JP1.2 (B), JP3.1, Q1.2 (B1), Q2.2 (B), R13.1, R14.1
C1: C3.2, J5.6, Q1.6 (C1), Q2.1 (C), R16.2, U1.6 (-)
C2: J2.10, J5.3, Q1.3 (C2), Q3.1 (C), R18.2, R19.2, R20.2, R21.2, U1.2 (-)
E: J5.1, J5.4, Q1.1 (E1), Q1.4 (E2), Q2.3 (E), Q3.3 (E), R17.1
GND: C1.1, C2.1, C6.1, C7.1, J1.3, J2.1, J2.2, J2.13, J2.14, J3.1, J3.2, J3.13, J3.14, J5.5, JP3.2, JP4.1 (A), Q1.5 (B2), Q3.2 (B), Q5.3 (E), R12.2, R15.1, R26.1, R30.1, R34.2, R39.1, U1.3 (+), U1.5 (+), U1.10 (+)
GNDD: C8.1, J1.4, U3.7 (GND)
unnamed: C3.1, JP2.2 (B), R17.2, U1.7
unnamed: C4.2, R22.2, R24.2, U2.9 (-)
unnamed: C5.1, JP5.2 (B), R34.1, R36.1, R37.2, U2.3 (+)
unnamed: C9.2, J3.4
unnamed: C10.2, J3.8
unnamed: C11.2, J3.12
unnamed: C12.2, J3.6
unnamed: C13.2, J3.10
unnamed: D1.1 (K), JP2.1 (A)
unnamed: D1.2 (A), R15.3
unnamed: J4.1, R41.2
unnamed: J4.2, R42.2
unnamed: J4.3, R43.2
unnamed: J6.1, R31.1, R33.1, U2.12 (+)
unnamed: JP1.1 (A), R10.2, R11.2, R12.1, R13.2
unnamed: JP4.2 (C), Q4.1 (S)
unnamed: JP6.1, Q6.1 (C), R51.2
unnamed: JP6.4, R49.1
unnamed: Q4.3 (D), R25.2
unnamed: Q5.1 (C), R37.1, U2.5 (+)
unnamed: Q5.2 (B), R35.1
unnamed: Q6.2 (B), R50.1
unnamed: R1.2, R2.1
unnamed: R2.2, U1.12 (+)
unnamed: R2.3, R3.1
unnamed: R8.2, R9.1, U1.8
unnamed: R9.2, R10.1, R11.1
unnamed: R14.2, R15.2
unnamed: R23.1, R26.2, U2.10 (+)
unnamed: R24.1, R25.1
unnamed: R27.1, R28.1
unnamed: R28.2, R30.2, R31.2
unnamed: R28.3, R29.2
unnamed: R36.2, R38.1, U2.6 (-)
unnamed: R40.2, R48.2, U2.1
unnamed: R41.1, R44.1, U3.1
unnamed: R42.1, R45.1, U3.2
unnamed: R43.1, R46.1, U3.5
unnamed: R47.1, R49.2, U3.13
unnamed: R48.1, U3.9
unnamed: R50.2, U3.11
unnamed: U3.3, U3.4
unnamed: U3.6, U3.10, U3.12
VCC: C1.2, C7.2, J1.1, Q6.3 (E), R1.1, R16.1, R27.2, R52.1, U1.4 (V+), U2.4 (V+)
VEE: C2.2, C6.2, J1.5, R3.2, R29.1, R51.1, R52.3, U1.11 (V-), U2.11 (V-)
V_control: J2.3, R4.2
V_control_2: J2.5, R5.2
V_control_3: J2.7, R6.2
V_control_raw: J2.9, R4.1, R5.1, R6.1, R7.1, R8.1, U1.9 (-)
V_expo: R21.1, R22.1, R23.2, U1.1
V_lin_pitchmod_1: J2.4, R18.1
V_lin_pitchmod_2: J2.6, R19.1
V_lin_pitchmod_3: J2.8, R20.1
V_pwm: J2.12, U2.2 (-)
V_tune: R7.2, R52.2
ctl_override: J2.11, JP6.3, Q4.2 (G), R32.1
pulse: C12.1, J3.5, R39.2, R40.1
rmpulse: C9.1, J3.3, U3.8
saw_ctl: JP6.2, R35.2
sawtooth: C13.1, J3.9, R38.2, U2.7
square_ctl: C11.1, J3.11, R32.2, R33.2, U2.14
triangle: C4.1, C5.2, C10.1, J3.7, JP5.1 (A), U2.8, U2.13 (-)
var_vsource: JP4.3 (B), U1.13 (-), U1.14

Notes on the sheet:
waveform generation
alternative transistors only equip one pair
Q5 cannot be replaced by a mosfet due to the parasitic diode inside a FET. Do replace it for some crunchy wave- shaping, though.
vco core
Just a hacky way of applying an adjustable voltage with an adjustable inner resistance. You can leave out R27-R29 and equip R30 with a 0R resistor. That will cause a slightly off-center triangle wave and a shifted sawtooth, at least with the LM324.
to put the pulse signal roughly at the same level as the others (ca. 3V peak-peak. others can range from 1.5V to ca. 7V)
R22 * C4 should be 100µs, this affects the freq. range R22 : R24+R25 must be 2:1, this affects the triangle shape R23 : R26 must be 1:1, this affects the triangle shape R31 : R33 should be 1:1 to 1:5, this affects tri amplitude and frequency range. Too large R31 may cause distortion R36 : R38 shoul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
ca 290mV/oct
adjustable offset can be achieved by running a wire from the gnd adjust jumper to V_lin_pitchmod_3 (TODO: set the resistor value accordingly)
10k is a reasonable value here. The poti gives plenty room.
must be of same (or similar) size as the rossum resistor. also change the vexpo potis value accordingly
R16 determines the I_C current through Q1B when Q1B's base is at GNDREF. Together with V_tune, it determines the pitch. Choose R14 and V_tune such, that Q1A's base is at around GNDREF for "sane" pitches.
for Q1B, the following holds true: I_C = const * exp(V_B / VT) with VT=26mV (thermal voltage of a transistor) now this means that V_expo will double every (log(2) * 26mV) = 18mV. Note that VT is temperature dependent. When the temperature rises, VT rises and so the input voltage must rise too. The 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
thermal compensation
Rossum compensation
ca 18mV/oct
ca 19mV/Oct
ca 24mV/oct
VCC-GND should be <= 6V absolute maximum: 7V). Otherwise, 5V and VCC must be separated
Sawtooth generation and digital ring modulation (sawtooth is basically a square_ctl ringmodulated triangle)
Jumper configurations for JP6: 12 + 34: sawtooth wave with 4x ringmod 12: triangle wave with 4x ringmod (pin 4 can be used as fifth ringmod) 23: sawtooth, no ring mod. Choose this when no 74HC86 is installed.
TODO: or 1k?
shift the 0/5V levels up to Vcc / Vee levels. Q5 wants to be driven with these
Optional components: Rossum compensation: can be left out, you must close JP1 then. Effect: No precise 1V/oct tuning possible (stable, but non-linear frequency response; requires digital compensation) Sawtooth gen / dig.ring.mod.: can be left out, you must connect JP5's pin2+3. Effect: No ring modu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
GNDREF and GNDD may be connected, but this might have a negative impact on the frequency stability.
or 470n
do not equip R34. 10-100k are fine, but R37+Q5 are enough for our purpose.
remove the DC offset. This doesn't matter for normal operation, but for DCO operation, where R27-R31 have no effect and thus, the signal is not centered.
For another interesting square wave variation, connect ctl_override (JP6, pin 3) to J4. Then play around with the PWM voltage and watch rmpulse. Apply narrow periodic pull-to-GND pulse to U2's pin5 (J6) for soft sync.
originally connected to var_vsource in error. (*)
todo: maybe 47n?
TODO: test 1n
2x 1Meg for Q4 compensation less (possibly 0 Ohm) for other purposes
1Meg
111k
Rs that can scale together: x: R16, x: R21, 1/x: R14 TODO test!
10k
Note (*): R26 was connected to var_vsource at first. (in error). Connecting R26 to GND and Q4 to var_vsource at nearly the same potential difference < 0.1mV) led to very good tracking results. Maybe the tracking accuracy is not a calibration issue, but an opamp overload situation.

Board: 2 copper layers, 71.6 x 44.7 mm, 87 parts (37 on the bottom side), 70 nets.

## Code that names these connections

File firmware-rust/src/main.rs (part):

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use shared_bus;
use noop_bus_mutex;

static mut GLOB_EXTI_PIN : MaybeUninit<gpioa::PA7<Input<Floating>>> = MaybeUninit::uninit();
static mut GLOB_TX : MaybeUninit<serial::Tx<stm32::USART1>> = MaybeUninit::uninit();
static mut GLOB_TIMER : MaybeUninit<timer::CountDownTimer<stm32::TIM2>> = MaybeUninit::uninit();

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
type MyUsbPins = (stm32f1xx_hal::gpio::gpioa::PA11<stm32f1xx_hal::gpio::Input<stm32f1xx_hal::gpio::Floating>>, stm32f1xx_hal::gpio::gpioa::PA12<stm32f1xx_hal::gpio::Input<stm32f1xx_hal::gpio::Floating>>);
type MyUsbBus = stm32_usbd::bus::UsbBus<MyUsbPins>;

type MySpiPins = (
	gpiob::PB13<Alternate<PushPull>>,
	gpiob::PB14<Input<Floating>>,
	gpiob::PB15<Alternate<PushPull>>
);

type MySpi = stm32f1xx_hal::spi::Spi<
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		#[init(core::ptr::null_mut())]
		exti_pin_ptr : *mut Pxx<Input<Floating>>,
		tx : serial::Tx<stm32::USART1>,
		led : gpioc::PC13<Output<PushPull>>,
		usb_dev : usb_device::device::UsbDevice<'static, MyUsbBus>,
		midi : usbd_midi::MidiClass<'static, MyUsbBus>,
		mytimer : timer::CountDownTimer<stm32::TIM2>,
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		let mut gpiob = dp.GPIOB.split(&mut rcc.apb2);
		let mut gpioc = dp.GPIOC.split(&mut rcc.apb2);

		// Configure the on-board LED (PC13, green)
		let mut led = gpioc.pc13.into_push_pull_output(&mut gpioc.crh);
		led.set_high().ok(); // Turn off

		// Configure the USART
		let gpio_tx = gpioa.pa9.into_alternate_push_pull(&mut gpioa.crh);
		let gpio_rx = gpioa.pa10;
		let serial = serial::Serial::usart1(
			dp.USART1,
			(gpio_tx, gpio_rx),
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		// Configure USB
		// BluePill board has a pull-up resistor on the D+ line.
		// Pull the D+ pin down to send a RESET condition to the USB bus.
		let mut usb_dp = gpioa.pa12.into_push_pull_output(&mut gpioa.crh);
		usb_dp.set_low().ok();
		delay(clocks.sysclk().0 / 100);
		
		let usb_dm = gpioa.pa11;
		let usb_dp = usb_dp.into_floating_input(&mut gpioa.crh);

		*USB_BUS = Some( UsbBus::new(dp.USB, (usb_dm, usb_dp)) );
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		writeln!(tx, "spi...");

		// SPI
		let mcp_ss : OldOutputPin<_> = gpiob.pb12.into_push_pull_output(&mut gpiob.crh).downgrade().into();
		let mcp2_ss : OldOutputPin<_> = gpiob.pb11.into_push_pull_output(&mut gpiob.crh).downgrade().into();
		let sck = gpiob.pb13.into_alternate_push_pull(&mut gpiob.crh);
		let mosi = gpiob.pb15.into_alternate_push_pull(&mut gpiob.crh);
		let miso = gpiob.pb14;

		let spi = spi::Spi::spi2(dp.SPI2, (sck, miso, mosi), spi::Mode { phase : spi::Phase::CaptureOnFirstTransition, polarity : spi::Polarity::IdleLow }, 5.mhz(), clocks, &mut rcc.apb1);
		let shared_spi : &'static MySharedSpiManager = singleton!(:MySharedSpiManager =
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		let mcp4822 = singleton!(:RefCell<Mcp> = RefCell::new(mcp49xx::Mcp49xx::new_mcp4822(shared_spi.acquire(), mcp_ss)) ).unwrap();

		let bu2505_ld_pin = gpiob.pb10.into_push_pull_output(&mut gpiob.crh).downgrade();
		let mut spi_bla = shared_spi.acquire();
		let mut bu2505 = bu2505fv::create_reversed(bu2505_ld_pin, &spi_bla);

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		// EXTI
		p.NVIC.enable(stm32::Interrupt::EXTI9_5);

		let mut exti_pin = gpiob.pb9.into_floating_input(&mut gpiob.crh);
		exti_pin.make_interrupt_source(&mut afio);
		exti_pin.trigger_on_edge(&dp.EXTI, Edge::RISING_FALLING);
		exti_pin.disable_interrupt(&dp.EXTI);

		let mut exti_pin2 = gpiob.pb8.into_floating_input(&mut gpiob.crh);
		exti_pin2.make_interrupt_source(&mut afio);
		exti_pin2.trigger_on_edge(&dp.EXTI, Edge::RISING_FALLING);
		exti_pin2.disable_interrupt(&dp.EXTI);
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
## Commit log

2019-05-30 vco: VGND circuitry
2019-05-30 fixed that shit
2019-05-30 vco :)
2019-05-30 sawtooth broken?
2019-05-30 add comments, fix frequency range
2019-05-30 expo converter
2019-05-30 finished
2019-06-08 filter feedback
2019-06-09 rotate R3 and C1
2019-06-28 vco: add hint about mosfet as Q1
2019-06-28 vco: adapt sawtooth generation to actual ciruitry on the breadboard
2019-06-28 more comments
2019-06-28 various simulations
2019-06-28 measure-vco schematic
2019-06-28 readme, license
2019-06-28 initial commit to measure_vco/firmware
2019-06-28 measure frequency
2019-06-28 tetris
2019-06-28 printf support
2019-06-28 envelope via dac
2019-06-28 readme
2019-06-28 experiment
2019-06-29 play test tones
2019-06-29 oops, forgot the testing code
2019-06-29 corrected commitid
2019-06-30 test tones for adjusting R10
2019-06-30 measure_vco: test various timer speeds
    changed the timer frequency to 100kHz
2019-06-30 try timer freq 1MHz
2019-06-30 measure various waittimes instead
2019-07-02 measure five periods, pwm ratio. use adaptive timer prescaler
2019-07-02 remove dead tetris code
2019-07-02 auto-tune based on two probes to have proper frequency expectations
2019-07-04 experiment++
2019-07-04 fix directory naming
2019-07-05 analyze_stability.py
2019-07-13 split analysis tooling
2019-07-27 robustify file parsing
2019-07-27 thermal_stability.py
2019-07-27 expo_thermal_compensation/
2019-07-27 improve plotting: draw frequency ticks
2019-07-27 add continuous plotting mode
2019-07-28 measure_vco schematic: reality update
2019-07-28 schematic: add thermal and rossum compensation
2019-07-28 vco_mk1 schematic. nearly finished
2019-07-28 ignore bak files
2019-07-29 add buffer to measure_vco schematic
2019-07-29 more vco_mk1
2019-07-29 vco_mk1: add triangle center and amplitude potis
2019-07-30 vco_mk1: eliminated last structural todos
    still todo: value selection
2019-07-30 move stuff around
2019-07-30 remove duplicate solder bridges
2019-07-30 consistent naming
2019-07-31 pre-name some components
2019-07-31 annotate all components
2019-07-31 component selection 80%
2019-08-01 layout wip
2019-08-02 layout wip2
2019-08-03 more fiddling
2019-08-03 fix XOR schematic
2019-08-03 better ring modulation. improved comments
2019-08-03 annotate and add footprints
2019-08-04 remove cruft
2019-08-04 add high pass filter for sawtooth/square generation
    this fixes sawtooth/square generation when running
    in DCO mode.
2019-08-04 add comment about deepmind-ish square variation
2019-08-06 soft sync
2019-08-06 confirmed: vco core and waveform generation (and fixes)
2019-08-06 confirmed: expo
2019-08-07 vco1.sch confirmed.
    TODO: check designated values for R13, R14, R19, C3
2019-08-07 gitignore
2019-08-08 triangle center adjust: add 0-Ohm-resistor to GNDREF
2019-08-10 resolved last todo
2019-08-10 the great component name overhaul
2019-08-10 fix bug with pulse ring modulation
2019-08-10 footprints
2019-08-10 working config with clean slate PCB
2019-08-10 combined transistor footprint
2019-08-10 grouped all components into logical groups
2019-08-10 placement 1/3
2019-08-10 rough layout for U3
2019-08-10 rough layout for U2
2019-08-10 placement3/3
2019-08-10 rough layout for U1
2019-08-10 improved double transistor
2019-08-11 routing
2019-08-11 slight adjustments
2019-08-11 first pass layout clusterfuck
2019-08-11 improved grounding a bit
2019-08-11 add windfisch logo
2019-08-11 added windfisch
2019-08-11 tweaket copper pour clearance
2019-08-11 clean slate reroute with cleaner layout
2019-08-11 shrink gndplane, add texts
2019-08-11 shrink edge cuts, fix texts
2019-08-11 done. DRC passed
2019-08-11 increase text thickness
2019-08-12 add JLCJLCJLCJLC text
2019-08-12 alternative TO92 footprint, oops
2019-08-12 new routing for improved placement
2019-08-12 added cute windfisch silkscreen
2019-08-12 refactored libraries
2019-08-12 partial merge of the libraries from master
2019-08-12 optimized silkscreen
2019-08-12 minor silkscreen optimizations
2019-08-12 added silkscreen labels and logos
2019-08-12 added spitfire logo to footprints
2019-08-12 final version and gerber files
2019-08-12 fabrication outputs
2019-08-12 added README and updated file structure to new naming conventions
2019-08-12 rename vco_mk1 board -> vco_mk1_windfisch
2019-08-12 readme++
2019-08-12 typo
2019-08-19 fix component references in schematic descriptions
2019-08-19 be clear about schematic variants
2019-08-19 fab output readme
2019-09-12 add tool for comparing frequency deviation graphs
2019-09-12 fix compare tool
2019-09-14 move printing out of the ISR
2019-09-14 remove unneccessary voltage_val
2019-09-14 time and cycle limit for the timer
2019-09-14 fix bug
2019-09-14 refactor, add measure_frequency_at_codepoint() function
2019-09-14 add search_codepoint_for_frequency() function
2019-09-15 README for vco_mk1
2019-09-15 vco_mk1 rev02
2019-09-15 fix printf %f
2019-09-15 measure the frequency stability at various pitches
2019-09-15 tool for measuring the frequency stability over time
2019-09-15 also display pulse width stability vs time
2019-09-20 it works with the F103 \o/
2019-09-20 configurable hardware config
2019-09-23 experiment: compare breadboard, blue and red board
2019-09-27 VCA schematic
2019-09-28 changed vca
2019-09-28 firmware copied from measure_vco/firmware. added BU2505FV dac support
2019-10-25 fix dac pins, refactor midi firmware
2019-10-25 update measure_vco schematics
2019-10-25 firmware attempts in rust
2019-10-25 fix some bugs and warnings
2019-10-25 use the Right indentation style (i.e., tabs)
2019-10-25 fix most warnings
2019-10-25 factor out init() and main()
2019-10-28 some progress
2019-10-28 use rtfm. WIP
2019-10-29 this does not work...
2019-10-30 ugly kludge to share vco between init() and main()
2019-10-30 it seems to work
2019-10-31 it compiles!!
2019-10-31 IT WORKS!! can measure frequency
2019-11-01 calibration should[tm] work now
2019-11-01 usb works
2019-11-01 play midi notes
2019-11-01 increase SPI clock speed
2019-11-01 use the usb interrupt instead of polling periodically
2019-11-02 test envelope
2019-11-02 generic reverse_bits implementation
2019-11-02 bu2505 and envelope test
2019-11-02 envelopes work \o/
2019-11-02 calibration command via controller 91
2019-11-03 better calibration routine
2019-11-03 remove commented out code
2019-11-03 schematic for the new firmware setup
2019-11-09 use repeatable envelopes as lfo
2019-11-09 working VCF (npn variant)
2019-11-09 VCF with pnp
2019-11-11 fixes
2019-11-11 voice board schematic
2019-11-12 boards++
2019-11-12 proper VCF ctl input stage
2019-11-12 general purpose filters, VCA input stage
2019-11-12 some todos
2019-11-13 add pre-bias poti for the VCF
2019-11-13 add input preattenuation
2019-11-13 put measurement clamping circuitry on the voice board
2019-11-13 rename RV->R
2019-11-13 pre-annotated
2019-11-13 annotated
2019-11-14 rearranged schematic
2019-11-14 voice board: footprint association
2019-11-14 more footprints
2019-11-15 voice board: fixes, vca layout
2019-11-15 voice board: vcf
2019-11-15 mixer and lowpass filters
2019-11-16 finished layout for all individual sections
2019-11-16 small todos
2019-11-17 fix voice board: add power to the OpAmp -.-
2019-11-17 fix voice board: layout
2019-11-17 voice board: add expo
2019-11-17 minor fixes
2019-11-18 clean up schematic
2019-11-18 flip footprint
2019-11-18 flip another footprint
2019-11-18 replace some SMD caps with thts
2019-11-18 flip some potis
2019-11-19 routing improvement
2019-11-19 move most things together
2019-11-19 lots of labels
2019-11-21 move VCF poti to VCF side
2019-11-21 fix todos
2019-11-21 fix vca output
2019-11-21 final todos?
2019-11-22 use film caps for the filter
2019-11-22 increase spacing of the filter
2019-11-22 silk screen
2019-11-22 silk screen final?
2019-11-22 ground plane
2019-11-23 final version of voice board mk I
2019-11-23 voice board: towards production
2019-11-23 fabrication files and readme for voice board
2019-11-24 control prototype board
2019-11-24 last fixes for control and voice board:
    control board: add 3V3 header
    voice board: mcp4822 silkscreen
2019-11-28 fix 3d models in footprint library
2019-11-28 fix paths to schematic and footprint libraries
2019-11-28 update footprints in boards, use local runtron 3d model (on my machine only)
2019-11-28 add images
2019-12-06 fablayer wip
2019-12-07 pretty fabrication layers for voice and control board
2019-12-16 control board docs and rev02
2019-12-16 blue pill board selection
2019-12-20 voice board errata
2019-12-20 Fix swapped resistors in voice board's sync circuit
    Fixes #18
2019-12-20 voice board: silk screen fixes
    Fixes #20
2019-12-20 voice board rev02
2019-12-20 control board: more silk screen fixes
2019-12-27 schematic fixes
2019-12-27 add BU2505 dac channel labels
2020-01-03 add archive.org fallback links
2020-01-03 tiny doc update
2020-01-28 recommended configuration
2020-02-05 simulation tooling
2020-02-09 analysis tooling for the vco simulation
2020-02-09 auto-detect time range
2020-02-09 simulation tooling sort of works
2020-02-13 add usage hint
2020-02-13 vca simulation
2020-02-13 vcf simulation. does not work
2020-02-15 vcf simulation works :)
2020-09-06 info about the 64 code effect
2020-09-08 Add commit string and build date to firmware
2020-09-08 reduce envelope update debug log
2020-09-08 some VCF schematic changes
2021-01-16 voice board: remove DAC potis, tie down dangling op amp
2021-01-16 updated resistor values to match current situation
2021-01-16 add capacitors in an attempt to fix the buzzing
2021-01-17 reality update for the control board:
    - reduce R4/R5 from 100k to 2.2k
    - capacitors across R5 and U1
    - protection diode for U1
    - source termination resistor for SCK signal
2021-01-17 cleaned up vcf simulation
2021-01-19 VCF simulation and plotting
2021-01-19 compare filter responses for various control currents
2021-01-20 greatly speed up calculation
2021-01-21 calculate total harmonic distortion
2021-01-23 Plot total harmonic distortion and wave form
2021-01-23 reduce plot quality for speed
2021-01-24 nice plot
2021-01-25 plot fixes
2021-01-25 draft mode
2021-01-25 swap x and y
2021-01-25 add separate legend
2021-01-27 improve plot output and write it to pdf file
2021-01-27 nicer CLI for the plotting tool
2021-01-27 multi bode plot
2021-01-29 nice bode plot
2021-01-31 Allow writing bode plots to files
2021-01-31 Plot tooling and schematics for VCF simulation
2021-01-31 plot_all.sh script
2021-01-31 voiceboard patch3; still wip
2021-01-31 vcf_unbuffered_capacitors* now correctly reflect patch2
2021-01-31 Use TL074, not LM324 in vcf simulation
2021-01-31 Add plotting support for 2 stage amps
2021-02-01 Fix plot_all.sh
2021-02-06 Changed VCA simulation
2021-02-06 dual vca simulation for voltage controlled distortion
2021-02-06 vca simulation++
2021-02-07 changed vca2 to exponential input
2021-02-07 vca with voltage controlled distortion that does not affect volume
2021-02-07 that opamp buffer seems unneeded
2021-02-09 vca thd plot
2021-02-09 thermally compensated expo current source for VCA, pinch off resistor
2021-02-10 nice and slim exponential VCA simulation
2021-02-11 voltage controlled distortion with rudimentary gain compensation
2021-02-12 improved gain compensation
2021-02-15 Tried out instrumentation amplifier for VCF
2021-02-15 vcf: resonance bode plots
