# Repository Windfisch/analog-synth

File README.md:

# Analog Synthesizer Project

This project attempts to build a **low-cost** analog synthesizer based on
well-available components like LM324 or TL084 op-amps, which is **easy
to understand and learn**.

The goal is a semimodular synthesizer which is compatible to existing other
systems, where possible. The following features are planned:

- two 1-Volt-per-octave voltage controlled oscillators (VCO) with triangle,
  PWM-able square, and sawtooth waveforms
- the option to use them as digital controlled oscillators (DCO)
- a voltage controlled filter (VCF)
- a voltage controlled amplifier (VCA)
- digital or analog envelope generators
- analog waveshaping and distortion circuits
- USB or MIDI interface based on a STM32 microcontroller

For the sake of simplicity, the following trade-offs are being made:

- exact component selection is traded for automatic or semiautomatic tuning
  where possible:
- no exact 1-volt-per-octave frequency behaviour: The VCO's frequency response
  is not 100% perfect. While commercial synthesizers offer complex analog
  compensation circuitry, this project will measure the frequency deviation
  and compensate for it in software at the stage of the
  MIDI-to-Control-Voltage interface.
- no voltage controlled analog envelopes: These are complicated to build, and
  the difference to digital envelopes or LFOs is not noticeable.

## Required Hardware

So far, apart from standard resistors and capacitors, the synth uses LM324 op
amps, and BC547 / 2N3904 bipolar-junction-transistors and 2N7000 MOSFETs.

The control logic and its firmware is currently based upon a STM32F103 based
*"blue pill"* board, which can be sourced for less than 2 EUR from your
favourite chinese seller. ([Note: look for those boards with a rectangular white reset
switch, not a flat round one.](bluepill.md))
Previous versions were developed for the
[STM32F411 discovery board](https://www.st.com/en/evaluation-tools/32f411ediscovery.html),
which should still work after adjusting the Makefile.

## Repo Contents

under `simulation/`, some circuitry was tested (using the KiCAD SPICE
simulation).

Most importantly, `simulation/vco` shows a functional exponential VCO. There
are detailed annotations on which part serves which purpose.

[simulation/software/](simulation/software/) contains tooling to do transient
simulation on parts of the synth with different control voltages and to further analyze
the results.

Under `measure_vco/` you can find the tooling and test results for measuring
the pitch deviation of the VCO.

[hardware/](hardware/) contains the actual hardware boards and drafts:

  - The [VCO development board mk I](hardware/vco_mk1).

  - A [voice supplement board](hardware/voice_board) containing a VCA, VCF and
    some utility functions.
    
  - A [main control board](hardware/control_board_prototype) with a STM32 blue
    pill board, utility DACs and the supply voltage generation.

## Setup

To build libopencm3:

```
git submodule update --init
make -j8 -C libopencm3
```

If you're using a STM32F411 board, you must adjust `measure_vco/firmware/Makefile`
and use the `DEVICE=stm32f411re` instead of the `DEVICE=stm32f103c8t` line.

To measure the vco frequency response:

```
cd measure_vco/firmware
make
```

then do whatever is neccessary to flash the program onto your board. For the blue
pill board, putting it into bootloader mode by jumpering BOOT0 to 1, resetting, and
calling `stm32flash -w dac_test.bin /dev/ttyUSB0` does the job, while for my
STM32F411-discovery, which has a non-standard blackmagic firmware on the STLINK chip, it is:

```
arm-none-eabi-gdb dac_test.elf # make sure it loads the .gdbinit file
load
run
```

Connect the pins correctly, then record the output with an UART adapter
(or using the blackmagic uart device).

## Licensing

All software, firmware and schematics are released under the terms of the [GPL3 license](LICENSE.md).
Note that this does not include the `simulation/**/*.lib` files needed for
simulation. Vendor licensing as noted in the respective files applies.

## KiCad design hardware/control_board_prototype/control_board_prototype.kicad_pcb

File hardware/control_board_prototype/README.md:

Control Board mk I
==================

The main board of the synth: It accepts a STM32F103 Blue Pill board and offers
two 10-channel DACs. Additionally, it contains a voltage converter, a virtual
ground circuit and pin headers for power distribution.

Setup
-----

Adjust to R2 to 540 Ohms to get a supply voltage of 10V.

U3 is optional. If U3 is equipped, do not close JP1. (C1, C2, R4 and R5 can
be left out in this case.) Otherwise, do close JP1.

JP2 controls whether the digital ground is connected to the analog ground, or
whether DGND is a separate buffered voltage source.

Similarly, JP3 allows to switch between the analog supply voltage and the
blue pill board's 5V supply voltage.

Recommended configuration
-------------------------

**Use Vdd = Vcc (JP3).** Taking Vdd from the blue pill board creates weird
"digital singing" on the audio signal.

**Use a separate dgnd (JP2).** Joining agnd and dgnd together causes strong
humming (approx. 100Hz; I measured 116Hz?!) and buzzing (from the SPI
bus; completely goes away as long the BU2505FV DAC isn't used (i.e.,
during startup/init), reduced when the MCP4822 isn't connected to the
SPI bus, very present when it is). Using a separate GND completely
cancels the humming, and reduces the buzzing to ~-70-80dB when the
VCA is closed, but still audible if the VCA is open).

A **TLE2426** ground splitter (U3) seems to be **unneccessary**.

Revisions
---------

- rev01: Has no marking and no wind fish on the back side.
- rev02: Small overlapping silk screen fixes. Has a wind fish and "rev02" on the back side. Was never fabricated.

Tested configuration
--------------------

rev01 has been used successfully with the following configuration:

- U2 was changed to TL072.
- JP1 closed, U3 not equipped.
- JP2 (dgnd select) in *sep* configuration.
- JP3 (Vdd select) in *blue pill* configuration.
- right half of the DAC section (i.e. J8, J10 and associated resistors
  and capacitors) not populated.

Fabrication
-----------

The gerber outputs used for fabrication of rev01 with [JLCPCB](https://jlcpcb.com) are
located under `fab/`.

The fabrication layers indicating which component values to put where
are [here](../voice_and_control_board_fab.pdf).

Parts:
A1: BluePill; BLUEPILL
C1, C2, C3, C4: 1u; CP_Radial_D5.0mm_P2.50mm
C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Conn_01x17_Male; PinHeader_1x17_P2.54mm_Vertical
J2: Conn_01x15_Male; PinHeader_1x15_P2.54mm_Vertical
J3: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J4, J5, J6, J11: Conn_02x10_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J7, J9, J12: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
J8, J10: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
JP1: SolderJumper_2_Open; SolderBridge
JP2, JP3: Jumper_3_Bridged12; SolderDipJumper3alt
R1: 220; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 1k; Potentiometer_Bourns_3296W_Vertical
R3: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R5: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: LM317; TO-220-3_Vertical
U2: LM358; DIP-8_W7.62mm
U3: TLE2426xLP; TO-92L_Inline
U4, U5: BU2505FV; SSOP20_and_breakout

Connections:
+3V3: A1.3V3 (3.3V), J12.1, J12.2, J12.3, J12.4, J12.5, J12.6, J12.7, J12.8
+VDC: J3.1, U1.3 (VI)
-VDC: C2.2, C4.2, J3.2, J5.1, J5.3, J5.5, J5.7, J5.9, J5.11, J5.13, J5.15, R3.2, R5.2, U2.4 (V-), U3.2 (COMMON)
GNDA: C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.1, J4.2, J4.4, J4.6, J4.8, J4.10, J4.12, J4.14, J4.16, JP1.2 (B), JP2.3 (B), U2.5 (+), U3.1 (OUT), U4.1 (VSS), U5.1 (VSS)
GNDD: A1.G (GND), C15.2, C16.2, C17.2, C28.2, C29.2, C30.2, J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, J6.13, J6.15, JP2.2 (C), U4.5 (~REVERSE), U4.20 (GND), U5.5 (~REVERSE), U5.20 (GND)
LD1: A1.PB10, J2.14, U4.15 (LD)
LD2: A1.PB11, J2.15, U5.15 (LD)
MISO: A1.PB14, J1.3, J11.1, J11.3, J11.5, J11.7, J11.9, J11.11, J11.13, J11.15
MOSI: A1.PB15, J1.4, J11.2, J11.4, J11.6, J11.8, J11.10, J11.12, J11.14, J11.16, U4.17 (DI), U5.17 (DI)
unnamed: A1.5V, JP3.1 (A)
unnamed: A1.PA0, J2.4
unnamed: A1.PA1, J2.5
unnamed: A1.PA2, J2.6
unnamed: A1.PA3, J2.7
unnamed: A1.PA4, J2.8
unnamed: A1.PA5, J2.9
unnamed: A1.PA6, J2.10
unnamed: A1.PA7, J2.11
unnamed: A1.PA8, J1.5
unnamed: A1.PA9, J1.6
unnamed: A1.PA10, J1.7
unnamed: A1.PA11, J1.8
unnamed: A1.PA12, J1.9
unnamed: A1.PA15, J1.10
unnamed: A1.PB0, J2.12
unnamed: A1.PB1, J2.13
unnamed: A1.PB3, J1.11
unnamed: A1.PB4, J1.12
unnamed: A1.PB5, J1.13
unnamed: A1.PB6, J1.14
unnamed: A1.PB7, J1.15
unnamed: A1.PB8, J1.16
unnamed: A1.PB9, J1.17
unnamed: A1.PB12, J1.1
unnamed: A1.PC13, J2.1
unnamed: A1.PC14, J2.2
unnamed: A1.PC15, J2.3
unnamed: C1.2, C2.1, JP1.1 (A), U2.1, U2.2 (-)
unnamed: C3.2, C4.1, JP2.1 (A), U2.6 (-), U2.7
unnamed: C5.1, J7.7, R6.1
unnamed: C6.1, J8.11, R7.1
unnamed: C7.1, J7.5, R8.1
unnamed: C8.1, J8.9, R9.1
unnamed: C9.1, J8.7, R10.1
unnamed: C10.1, J8.5, R11.1
unnamed: C11.1, J7.3, R12.1
unnamed: C12.1, J8.3, R13.1
unnamed: C13.1, J7.1, R14.1
unnamed: C14.1, J8.1, R15.1
unnamed: C18.1, J9.7, R16.1
unnamed: C19.1, J10.11, R17.1
unnamed: C20.1, J9.5, R18.1
unnamed: C21.1, J10.9, R19.1
unnamed: C22.1, J10.7, R20.1
unnamed: C23.1, J10.5, R21.1
unnamed: C24.1, J9.3, R22.1
unnamed: C25.1, J10.3, R23.1
unnamed: C26.1, J9.1, R24.1
unnamed: C27.1, J10.1, R25.1
unnamed: J7.2, R14.2, U4.12 (AO9)
unnamed: J7.4, R12.2, U4.13 (AO10)
unnamed: J7.6, R8.2, U4.18 (AO1)
unnamed: J7.8, R6.2, U4.19 (AO2)
unnamed: J8.2, R15.2, U4.9 (AO8)
unnamed: J8.4, R13.2, U4.8 (AO7)
unnamed: J8.6, R11.2, U4.7 (AO6)
unnamed: J8.8, R10.2, U4.4 (AO5)
unnamed: J8.10, R9.2, U4.3 (AO4)
unnamed: J8.12, R7.2, U4.2 (AO3)
unnamed: J9.2, R24.2, U5.12 (AO9)
unnamed: J9.4, R22.2, U5.13 (AO10)
unnamed: J9.6, R18.2, U5.18 (AO1)
unnamed: J9.8, R16.2, U5.19 (AO2)
unnamed: J10.2, R25.2, U5.9 (AO8)
unnamed: J10.4, R23.2, U5.8 (AO7)
unnamed: J10.6, R21.2, U5.7 (AO6)
unnamed: J10.8, R20.2, U5.4 (AO5)
unnamed: J10.10, R19.2, U5.3 (AO4)
unnamed: J10.12, R17.2, U5.2 (AO3)
unnamed: R1.2, R2.1, U1.1 (ADJ)
unnamed: R2.2, R3.1
unnamed: R4.2, R5.1, U2.3 (+)
SCK: A1.PB13, J1.2, J6.2, J6.4, J6.6, J6.8, J6.10, J6.12, J6.14, J6.16, U4.16 (CLK), U5.16 (CLK)
VCC: C1.1, C3.1, C17.1, C30.1, J4.1, J4.3, J4.5, J4.7, J4.9, J4.11, J4.13, J4.15, JP3.3 (B), R1.1, R4.1, U1.2 (VO), U2.8 (V+), U3.3 (IN), U4.11 (VCC), U5.11 (VCC)
VDD: C16.1, C29.1, J5.2, J5.4, J5.6, J5.8, J5.10, J5.12, J5.14, J5.16, JP3.2 (C), U4.10 (VDD), U5.10 (VDD)

Notes on the sheet:
TODO add 1-2 mcp dacs
powered via USB
Rail splitter: Virtual Ground
To power supply. E.g. a 12V LiPo or a lab PSU
364 Ohm for 9V 892 Ohm for 12V

Board: 2 copper layers, 98.0 x 54.4 mm, 76 parts (0 on the bottom side), 85 nets.

## KiCad design hardware/voice_board/voice_board.kicad_pcb

File hardware/voice_board/README.md:

Voice Board mk I
================

This board offers various utility features for a two-VCO-voice. It is designed
to be used together with two [../vco_mk1/](VCO mk I boards) and offers the
following features:

  - voltage controlled filter
  - voltage controlled amplifier
  - simple mixer
  - 2x square_ctl signal processing (buffering, sync pulse generation, clamping,
    which are missing from the VCO mk I board)
  - an expo converter (to be used as VCF input)
  - a 2-channel MCP4822 DAC for VCO control voltage generation
  - three general-purpose RC low pass filters

The gerber outputs used for fabrication with [JLCPCB](https://jlcpcb.com) are
located under `fab/`.

The fabrication layers indicating which component values to put where
are [here](../voice_and_control_board_fab.pdf).

Revisions
---------

**rev01** has no marking at the wind fish logo. It has been fabricated
using the gerber outputs in `fab-rev01/`. Please refer to the errata
below.

**rev02** can be identified by a *"rev02"* text close to the wind fish
logo. It has never been fabricated as it only contains silkscreen and
component value fixes.

Errata (rev01)
--------------

Some resistors in the sync pulse circuitry are wrong. R48 and R49 must
be changed from 10k to 1k. R50 and R51 must be changed from 1k to 10k.
This has been fixed in rev02.

R53 and R54's values are too weak, leading to very bad DAC performance
(e.g., non-monotonic DAC behaviour every 4 code points). Maybe a 100k
poti would work better; I fixed it by de-soldering the potis and wiring
U2's DAC output pins 6 and 8 to the connector J4 directly.

Errata (rev01)
--------------

R53 and R54's values are too weak, leading to very bad DAC performance
(e.g., non-monotonic DAC behaviour every 4 code points). Maybe a 100k
poti would work better; I fixed it by de-soldering the potis and wiring
U2's DAC output pins 6 and 8 to the connector J4 directly.

Parts:
C1: 470n; CP_Radial_D7.5mm_P2.50mm
C2, C7: 470u; CP_Radial_D7.5mm_P2.50mm
C3, C4, C5, C6: 47n; C_rect_smd_combo
C8, C9: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C10, C11, C17: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C13, C14, C15: any; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C16: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2: 3V3; D_DO-35_SOD27_P7.62mm_Horizontal
D3, D4: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
J2, J3, J6, J7, J8, J9: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
J4, J10: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J5: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
JP1, JP2: Jumper_2_Bridged; SolderDipJumper2alt
JP3: Conn_01x04_Male; SolderDipJumper4alt
Q1, Q3: BC327; TO-92_Inline
Q2, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16: BC557; TO-92_Inline
Q17, Q18, Q21, Q22: BC547; TO-92_Inline
Q19, Q20: 2N7000; TO-92_Inline
R1, R2, R18, R19, R39, R57, R58, R59, R72: 10k; Potentiometer_Runtron_RM-065_Vertical
R3, R4, R6, R14, R15, R17, R23, R24, R33, R66: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 200k; Potentiometer_Runtron_RM-065_Vertical
R7, R16, R20, R40: 100k; Potentiometer_Runtron_RM-065_Vertical
R8, R22, R46, R47, R48, R49, R70: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R9, R10, R11, R36, R37, R38, R41, R44, R45, R50, R51, R60, R61, R62: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12, R13: 20k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R21: 1Meg; Potentiometer_Runtron_RM-065_Vertical
R25: 47k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R26: 180; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R27, R35: 470; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R28, R29, R30, R31: 150; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R32: 220; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R34: 680; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R42, R43, R69: 1Meg; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R53, R54: 1k; Potentiometer_Runtron_RM-065_Vertical
R63, R64, R65: any; Potentiometer_Runtron_RM-065_Vertical
R67: 200k; Potentiometer_Bourns_3296W_Vertical
R68: 2.5k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R71: 10k; Potentiometer_Bourns_3296W_Vertical
U1: TL074; DIP-14_W7.62mm
U2: MCP4822; DIP-8_W7.62mm
U3: LM324; DIP-14_W7.62mm

Connections:
+3V3: C16.1, C17.1, J2.1, U2.1 (Vdd)
GND: C10.2, C11.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), J3.4, J8.4, J9.2, J10.2, Q3.2 (B), Q22.2 (B), R1.3, R2.3, R8.1, R15.2, R18.3, R19.3, R22.1, R26.1, R42.2, R53.3, R54.3, R57.3, R58.3, R59.3, U1.5 (+), U1.10 (+), U2.5 (~LDAC), U2.7 (Vss), U3.3 (+), U3.5 (+), U3.10 (+)
unnamed: C1.2, R7.1
unnamed: C2.1, Q5.2 (B), R27.1
unnamed: C2.2, R21.1, R22.2
unnamed: C3.1, Q11.1 (C), Q12.3 (E)
unnamed: C3.2, Q5.1 (C), Q6.3 (E)
unnamed: C4.1, Q12.1 (C), Q13.3 (E)
unnamed: C4.2, Q6.1 (C), Q7.3 (E)
unnamed: C5.1, Q13.1 (C), Q14.3 (E)
unnamed: C5.2, Q7.1 (C), Q8.3 (E)
unnamed: C6.1, Q8.1 (C), Q9.3 (E), R36.2
unnamed: C6.2, Q14.1 (C), Q15.3 (E), R37.2
unnamed: C7.1, R40.1
unnamed: C7.2, Q11.2 (B), R35.2
unnamed: C8.1, Q19.2 (G), R50.2
unnamed: C8.2, JP1.2 (B)
unnamed: C9.1, Q20.2 (G), R51.2
unnamed: C9.2, JP2.2 (B)
unnamed: C10.1, R53.1, U2.6 (VB)
unnamed: C11.1, R54.1, U2.8 (VA)
unnamed: C13.1, J5.2, R65.1
unnamed: C14.1, J5.4, R64.1
unnamed: C15.1, J5.6, R63.1
unnamed: J4.1, R54.2
unnamed: J4.2, R53.2
unnamed: J5.1, R65.2
unnamed: J5.3, R64.2
unnamed: J5.5, R63.2
unnamed: J8.1, R2.1
unnamed: J8.3, R1.1
unnamed: J9.1, R19.1
unnamed: J9.3, R18.1
unnamed: J10.1, R17.1, U1.1
unnamed: Q1.1 (C), R9.2, R13.2
unnamed: Q1.2 (B), R7.2, R8.2
unnamed: Q1.3 (E), Q3.3 (E), R10.1
unnamed: Q2.1 (C), R10.2
unnamed: Q2.2 (B), Q4.1 (C), Q4.2 (B), R14.2, R16.2
unnamed: Q3.1 (C), R11.2, R12.2
unnamed: Q10.1 (C), R34.2
unnamed: Q10.2 (B), Q16.1 (C), Q16.2 (B), R38.2, R39.2
unnamed: Q5.3 (E), Q11.3 (E), R34.1
unnamed: Q6.2 (B), Q12.2 (B), R28.2, R29.1
unnamed: Q7.2 (B), Q13.2 (B), R29.2, R30.1
unnamed: Q8.2 (B), Q14.2 (B), R30.2, R31.1
unnamed: Q9.2 (B), Q15.2 (B), R31.2, R32.1
unnamed: Q17.2 (B), R44.1
unnamed: Q18.2 (B), R45.1
unnamed: Q21.1 (C), R69.2, U3.6 (-)
unnamed: Q21.2 (B), R68.2, U3.8
unnamed: Q21.3 (E), Q22.3 (E), R70.1
unnamed: Q22.1 (C), R71.2, U3.2 (-)
unnamed: R12.1, R17.2, U1.2 (-)
unnamed: R13.1, R15.1, U1.3 (+)
unnamed: R6.2, R14.1, U1.7
unnamed: R20.2, R25.1
unnamed: R26.2, R27.2, R28.1, R35.1
unnamed: R33.2, R38.1, U1.8
unnamed: R36.1, R43.2, U1.13 (-)
unnamed: R37.1, R42.1, U1.12 (+)
unnamed: R40.2, R41.1
unnamed: R57.2, R60.1
unnamed: R58.2, R61.1
unnamed: R59.2, R62.1
unnamed: R66.1, R72.2
unnamed: R70.2, U3.7
PB12: J2.2, U2.2 (~CS)
PB13: J2.4, U2.3 (SCK)
PB15: J2.3, U2.4 (SDI)
VCC: J3.1, Q2.3 (E), Q4.3 (E), Q10.3 (E), Q16.3 (E), Q17.1 (C), Q18.1 (C), R16.1, R20.3, R39.1, R69.1, R72.3, U1.4 (V+), U3.4 (V+)
VEE: J3.3, Q9.1 (C), Q15.1 (C), Q19.1 (S), Q20.1 (S), R5.2, R9.1, R11.1, R20.1, R32.2, R46.1, R47.1, R50.1, R51.1, R72.1, U1.11 (V-), U3.11 (V-)
clamped1: D1.1 (K), D3.1 (K), J1.9, R48.1
clamped2: D2.1 (K), D4.1 (K), J1.10, R49.1
expo_in: J7.3, R67.2
expo_out: J7.2, J7.4, R71.1, U3.1
expo_raw: J7.1, R66.2, R67.1, R68.1, U3.9 (-)
mixer_out: J6.4, JP3.2, R60.2, R61.2, R62.2
square_ctl1: J1.1, R44.2
square_ctl2: J1.2, R45.2
square_ctl_buf1: J1.3, J1.5, J1.7, JP1.1 (A), Q17.3 (E), R46.2, R48.2
square_ctl_buf2: J1.4, J1.6, J1.8, JP2.1 (A), Q18.3 (E), R47.2, R49.2
sync_out1: J1.11, Q19.3 (D)
sync_out2: J1.12, Q20.3 (D)
vca_audio_in: C1.1, JP3.3
vca_ctl1: R1.2, R3.1
vca_ctl2: R2.2, R4.1
vca_ctl_raw: J8.2, R3.2, R4.2, R5.1, R6.1, U1.6 (-)
vcf_audio_in: JP3.1, R21.2
vcf_audio_out: JP3.4, R41.2, R43.1, U1.14
vcf_ctl1: R18.2, R23.1
vcf_ctl2: R19.2, R24.1
vcf_ctl_raw: J9.4, R23.2, R24.2, R25.2, R33.1, U1.9 (-)
vco1_in: J6.1, R57.1
vco2_in: J6.3, R58.1
vco3_in: J6.2, R59.1

Notes on the sheet:
differential to single-ended
differential pair (current controlled amplification)
current mirror as voltage controlled current source
Voltage controlled amplifier
triangle from VCO mk I
transistor buffer. square_ctl is very sensitive, loading it will affect the frequency and pulse width of the oscillator
input preattenuation. controls distortion
sawtooth from VCO mk I
bias network to keep the transistor bases >= 1 diode drop away from each other
feedback
sync pulse generation
transistor ladder VCF
mixer
offset compensation: the OpAmp would need to output exactly Vcc - 0.7V (i.e., the voltage at the transistor's base) in order to fully close the VCF. However, the OpAmp is limited to approx. Vcc-1.5V, so we inject some current through this trimming poti. When the OpAmp is at its Vmax, tune this poti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
should be 2x 47k maybe
set to 7.26k
set to ~~47k
should be 2x 47k maybe
set to 100k
set such, that with zero control input, the output of the op amp is just at maxi- mum (i.e., Vcc minus like 1 V or so)
general purpose low pass filters
or connect (-) with ~~100k to VEE (like the VCA)
clamp for the STM32 measure- ment pin
square_ctl swings between Vee and Vcc - 1.5V (circa). GNDREF is at (Vcc+Vee)/2, i.e. PE7 sees at least 3V for Vcc-Vee = 9V. The diodes protect the MCU pin from overvoltage (D1) and undervoltage (D2): The schottky diode D2 clamps away negative voltages (to approx. -200mV), while the zener diode D1 l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
voltage controlled filter
set to 2.18k
Expo converter
Mixer
control voltage DAC
place close to U2
TODO: keep or remove ground connection

Board: 2 copper layers, 83.8 x 72.4 mm, 127 parts (71 on the bottom side), 96 nets.

Notices in the files:
hardware/control_board_prototype/control_board_prototype.kicad_pcb:
Copyright (c) 2019 Florian Jung
