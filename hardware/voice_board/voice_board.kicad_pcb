File: hardware/voice_board/voice_board.kicad_pcb (KiCad board)
At the start: 2 copper layers, 130 parts, among them J1 Conn_02x06_Odd_Even, J2 Conn_02x02_Odd_Even, J3 Conn_02x02_Odd_Even, J4 Conn_01x02_Male, J5 Conn_02x03_Odd_Even, J6 Conn_02x02_Odd_Even, J7 Conn_02x02_Odd_Even, J8 Conn_02x02_Odd_Even, J9 Conn_02x02_Odd_Even, Q1 BC327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

Commit message: fix vca output
Parts:
- added J10: Conn_01x02_Male, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, B.Cu at (210.7, 35.3)
- moved R18 0.13 mm to (237.5, 31.2)
Routing:
- net Net-(J10-Pad1): track 2.23 -> 60.7 mm, vias 0 -> 5
- net GND: track 264.1 -> 318.1 mm, vias 4 -> 7
- net VCC: track 247.3 -> 269.1 mm, vias 6 -> 7
- net VEE: track 151.1 -> 134.6 mm
- net vcf_audio_out: track 62.7 -> 65.0 mm

Commit message: final todos?
Routing:
- net Net-(C2-Pad2): vias 2 -> 1
Changed lines of the file:
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@@
     (thickness 1.6)
     (drawings 31)
-    (tracks 797)
+    (tracks 796)
     (zones 0)
     (modules 131)
@@
     (uvia_drill 0.1)
     (add_net +3V3)
-    (add_net Envelope)
     (add_net GND)
-    (add_net LFO)
     (add_net "Net-(C1-Pad2)")
     (add_net "Net-(C10-Pad1)")
@@
     (add_net "Net-(C9-Pad2)")
     (add_net "Net-(J10-Pad1)")
-    (add_net "Net-(J3-Pad2)")
     (add_net "Net-(J4-Pad1)")
     (add_net "Net-(J4-Pad2)")
@@
     (add_net PB13)
     (add_net PB15)
-    (add_net PWM)
     (add_net VCC)
     (add_net VEE)
@@
   (segment (start 221.742 48.681) (end 221.655 48.768) (width 0.25) (layer F.Cu) (net 3))
   (segment (start 221.742 46.482) (end 221.742 48.681) (width 0.25) (layer F.Cu) (net 3))
-  (via (at 216.662 43.18) (size 0.8) (drill 0.4) (layers F.Cu B.Cu) (net 3))
   (via (at 218.313 48.768) (size 0.8) (drill 0.4) (layers F.Cu B.Cu) (net 3))
   (segment (start 216.662 43.18) (end 216.662 47.117) (width 0.25) (layer F.Cu) (net 3))

Commit message: use film caps for the filter
Parts:
- C3, C4, C5, C6: footprint Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder -> footprints:C_rect_smd_combo; moved to B.Cu
- moved R40 28.7 mm to (244.9, 31.2)
- moved C7 13.8 mm to (242.6, 40.1), turned to 270 degrees
- moved Q10 7.94 mm to (241.7, 49.4)
- moved Q11 7.94 mm to (241.7, 55.0)
- moved Q12 7.94 mm to (241.7, 60.6)
- moved Q13 7.94 mm to (241.7, 66.2)
- moved Q14 7.94 mm to (241.7, 71.8)
- moved Q15 7.94 mm to (241.7, 77.3)
- moved C3 7.16 mm to (238.3, 56.6)
- moved C5 6.99 mm to (238.3, 67.7)
- moved C4 6.86 mm to (238.3, 62.2)
- moved C6 1.90 mm to (233.3, 73.4)
Routing:
- net VCC: track 269.1 -> 227.7 mm, vias 7 -> 6
- net Net-(R40-Pad2): track 33.5 -> 68.8 mm
- net Net-(C7-Pad2): track 11.2 -> 24.7 mm
- net Net-(C6-Pad2): track 20.4 -> 31.7 mm
- net Net-(Q10-Pad1): track 2.47 -> 10.6 mm
- net VEE: track 134.6 -> 142.5 mm
- net Net-(Q15-Pad2): track 10.9 -> 18.8 mm
- net Net-(Q14-Pad2): track 10.3 -> 18.2 mm
- net Net-(Q13-Pad2): track 10.5 -> 18.5 mm
- net Net-(Q12-Pad2): track 8.63 -> 16.6 mm
- net Net-(Q11-Pad3): track 5.95 -> 13.9 mm
- net Net-(Q10-Pad2): track 22.0 -> 29.9 mm
- net Net-(C7-Pad1): track 6.23 -> 11.5 mm
- net Net-(C3-Pad2): track 5.11 -> 10.3 mm
- net Net-(C5-Pad2): track 4.31 -> 8.70 mm
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Other:
- board text added: "resonance"
- board text removed: "feedback/ resonance"

Commit message: increase spacing of the filter
Parts:
- moved Q10 2.03 mm to (243.8, 49.4)
- moved Q11 2.03 mm to (243.8, 55.0)
- moved Q12 2.03 mm to (243.8, 60.6)
- moved Q13 2.03 mm to (243.8, 66.2)
- moved Q14 2.03 mm to (243.8, 71.8)
- moved Q15 2.03 mm to (243.8, 77.3)
- moved C3 1.02 mm to (239.3, 56.6)
- moved C4 1.02 mm to (239.3, 62.2)
- moved C5 1.02 mm to (239.3, 67.7)
- moved C6 1.02 mm to (234.3, 73.4)
Routing:
- net VCC: track 227.7 -> 255.0 mm
- net Net-(C6-Pad2): track 31.7 -> 34.8 mm
- net Net-(C7-Pad2): track 24.7 -> 27.5 mm
- net Net-(R40-Pad2): track 68.8 -> 71.3 mm
- net Net-(Q10-Pad1): track 10.6 -> 12.6 mm
- net Net-(Q15-Pad2): track 18.8 -> 20.9 mm
- net Net-(Q14-Pad2): track 18.2 -> 20.2 mm
- net Net-(Q13-Pad2): track 18.5 -> 20.5 mm
- net Net-(Q12-Pad2): track 16.6 -> 18.6 mm
- net Net-(Q11-Pad3): track 13.9 -> 15.9 mm
- net Net-(Q10-Pad2): track 29.9 -> 31.9 mm
- net VEE: track 142.5 -> 144.6 mm
- net Net-(C5-Pad2): track 8.70 -> 9.72 mm
- net Net-(C4-Pad1): track 7.92 -> 8.93 mm
- net Net-(C3-Pad1): track 7.92 -> 8.93 mm
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
Commit message: silk screen
Parts:
- moved C10 9.25 mm to (196.3, 86.9)
- moved C11 9.25 mm to (196.3, 91.9)
- moved C8 9.25 mm to (219.2, 94.0)
- moved D3 9.25 mm to (225.0, 86.4)
- moved J4 9.25 mm to (209.6, 93.2)
- moved R49 9.25 mm to (234.7, 91.9)
- moved R56 9.25 mm to (197.1, 110.5)
- moved C12 9.25 mm to (197.3, 107.0)
- moved C16 9.25 mm to (193.0, 90.9)
- moved C17 9.25 mm to (193.0, 95.0)
- moved C9 9.25 mm to (240.0, 94.0)
- moved D1 9.25 mm to (225.3, 89.4)
- moved D2 9.25 mm to (233.9, 89.4)
- moved D4 9.25 mm to (234.2, 86.4)
- moved J1 9.25 mm to (228.3, 97.8)
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Routing:
- net expo_in: track 4.57 -> 8.67 mm
Other:
- board text added: "V/oct."
- board text added: "VCA"
- board text added: "VCF"
- board text added: "mix"
- board text added: "post gain"
- board text added: "vca"
- board text added: "vcf"

Commit message: silk screen final?
Parts:
- added G***: LOGO, windfisch:windfisch_smaller, B.Cu at (170.9, 95.2)
- added REF**: perfboard 3x9, footprints:perfboard 3x9, F.Cu at (176.4, 52.6)
- moved R68 29.6 mm to (173.5, 69.6)
- moved J7 29.6 mm to (192.0, 76.2)
- moved Q21 29.6 mm to (168.9, 73.9)
- moved Q22 29.6 mm to (168.9, 69.1)
- moved R66 29.6 mm to (194.6, 73.7)
- moved R67 29.6 mm to (192.0, 71.1)
- moved R69 29.6 mm to (176.3, 77.2)
- moved R70 29.6 mm to (170.4, 77.0)
- moved R71 29.6 mm to (187.5, 79.0)
- moved R72 29.6 mm to (197.6, 80.5)
- moved U3 29.6 mm to (187.5, 74.9)
Other:
- board outline added: 83.8 x 72.4 mm
- board text added: "(c) 2019 Florian Jung"
- board text added: "github.com/Windfisch/ analog-synth"
- board text added: "square_ctl"
- board text added: "voice board mk I"
- board text removed: "square_ctl buffer and sync"

Commit message: ground plane
Routing:
- net GND: track 318.1 -> 388.4 mm, vias 7 -> 10
- net VCC: track 255.0 -> 319.0 mm
- net VEE: track 144.6 -> 202.4 mm, vias 0 -> 5
